Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-05T12:26:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 05 12:26:47 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{60582A50-1F9E-4EC8-91BC-57F1347E1B12}\ifc * Database version: 5507 * Database creation date: Fri Mar 05 12:26:46 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 05 12:26:46 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 05 12:26:46 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Oasis_D+W, Oasis_D+W:Oasis_D+W:365255
In: Level 1
Type - Material: Glass
Type - Dimensions - A (vanjski rub stakla): 870 mm; D (vanjski rub stakla): 865 mm
Type - Identity Data - Boja profila: crna, bijela, srebrna; Izradio: Intelika do.o; Manufacturer: Aquaestil; Model: Oasis D+W; Type Name: Oasis_D+W; Web adresa: https://www.aquaestil.hr/hr/proizvodi/paravani/23-oasis-d-w.html
Type - Materials and Finishes - Material: Srebrni profil; Material glass: Prozirno staklo
Type - Other - Category: Generic Models; Family Name: Oasis_D+W
Pset_BuildingElementProxyCommon - Reference: Oasis_D+W:Oasis_D+W
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; TIP FIKSNE STIJENE: 70; TIP VRATA: 70; VIDLJIVOST drzaca rucnika: yes
Dimensions - Area: 4.8257 m2; Visina: 2000 mm; Visina drzaca rucnika: 656.19 mm; Volume: 0.018009 m3
Other - Family: Oasis_D+W: Oasis_D+W; Family and Type: Oasis_D+W: Oasis_D+W; Type: Oasis_D+W: Oasis_D+W; Type Id: Oasis_D+W: Oasis_D+W
Phasing - Phase Created: New Construction
